# Keil uVision project Project.uvprojx, settings and files
target STM3210C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c8t6
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;..\..\..\..\..\..\Drivers\BSP\STM32F1xx_c8t6_mini;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_ll_usb.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_pcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/STM3210C_EVAL
    ../../../../../../Drivers/BSP/STM3210C_EVAL/: stm3210c_eval.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usbd_cdc_interface.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c usbd_desc.c usbd_conf.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
software components: CMSIS:CORE 5.3.0
